# Keil uVision project fsm.uvprojx, settings and files
target debug_F413VGT6 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F413VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00050000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hub +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: HSE_VALUE=8000000 HSE_ON STM32F413xx DEBUG
  c include: ..\source\bsp;..\source\main;..\source\rtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group main
    ../source/main/: main.cpp
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
